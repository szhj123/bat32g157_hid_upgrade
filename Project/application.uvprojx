# Keil uVision project application.uvprojx, settings and files
target Application (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: BAT32G157GK64FB Cmsemicon
  pack: Cmsemicon.BAT32G157.0.12.0
  cpu: IRAM(0x20000000,0x08000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: application +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c misc: --diag_suppress=68 --diag_suppress=111  --diag_suppress=550
  c include: ..\CMSIS\Include;..\Device\Include;..\Driver\inc;..\User\Usb\usb_driver\inc;..\User\Usb\usb_phid_apl\inc;..\User\App;..\User\Drv;..\User\Hal;..\cm_backtrace;..\cm_backtrace\Languages\en-US;..\GUI;..\GUI\lvgl;..\GUI\lvgl_driver;..\GUI\lv_examples
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x200002c0 size 0x8000
  group Startup
    ../Device/Source/ARM/: startup_BAT32G157.s
  group Cmsis
    ../Device/Source/: system_BAT32G157.c
  group Library
    ../Driver/src/: clk.c gpio.c sci.c sci_user.c retarget.c dma.c intp.c iica.c iica_user.c
  group cm_backtrace
    ../cm_backtrace/: cm_backtrace.c
    ../cm_backtrace/fault_handler/keil/: cmb_fault.S
  group App
    ../User/App/: main.c app_mpu.c
    ../User/Usb/: usb_phid_descriptor.c usb_phid_custom_apl.c
  group Drv
    ../User/Drv/: drv_timer.c drv_task.c drv_ili9341.c drv_touch.c font.c drv_mpu.c drv_mpu_dmp_motion_driver.c
    ../User/Usb/usb_phid_apl/src/: usb_phid_driver.c
  group Hal
    ../User/Hal/: hal_timer.c hardware.c interrupt.c hal_task.c hal_lcd.c hal_touch.c hal_mpu.c
  group Usb_driver_lib
    ../User/Usb/usb_driver/: usb_phid_driver.lib
  group GUI
    ../GUI/lvgl/src/lv_core/: lv_disp.c lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c
    ../GUI/lvgl/src/lv_draw/: lv_draw.c lv_draw_arc.c lv_draw_basic.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_rect.c lv_draw_triangle.c lv_img_cache.c lv_img_decoder.c
    ../GUI/lvgl/src/lv_font/: lv_font.c lv_font_fmt_txt.c lv_font_roboto_12.c lv_font_roboto_16.c lv_font_roboto_22.c lv_font_roboto_28.c lv_font_unscii_8.c
    ../GUI/lvgl/src/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../GUI/lvgl/src/lv_misc/: lv_anim.c lv_area.c lv_async.c lv_circ.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_task.c lv_templ.c lv_txt.c lv_utils.c
    ../GUI/lvgl/src/lv_objx/: lv_arc.c lv_bar.c lv_btn.c lv_btnm.c lv_calendar.c lv_canvas.c lv_cb.c lv_chart.c lv_cont.c lv_ddlist.c lv_gauge.c lv_img.c lv_imgbtn.c lv_kb.c lv_label.c lv_led.c lv_line.c lv_list.c lv_lmeter.c lv_mbox.c lv_objx_templ.c lv_page.c lv_preload.c lv_roller.c lv_slider.c lv_spinbox.c lv_sw.c lv_ta.c lv_table.c lv_tabview.c lv_tileview.c lv_win.c
    ../GUI/lvgl/src/lv_themes/: lv_theme.c lv_theme_alien.c lv_theme_default.c lv_theme_material.c lv_theme_mono.c lv_theme_nemo.c lv_theme_night.c lv_theme_templ.c lv_theme_zen.c
    ../GUI/lvgl_driver/: lv_port_disp.c lv_port_indev.c
  group GUI_APP
    ../GUI/lv_examples/lv_apps/demo/: img_bubble_pattern.c demo.c
